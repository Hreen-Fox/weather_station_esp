// Подключаем необходимые заголовочные файлы
#include "web_server.h"        // Наш собственный заголовочный файл
#include "web_pages.h"         // HTML-страницы (хранятся в PROGMEM)
#include <ESP8266WiFi.h>       // Библиотека Wi-Fi для ESP8266
#include <LittleFS.h>          // Файловая система для хранения настроек

// Создаем глобальный объект веб-сервера на порту 80 (стандартный HTTP)
ESP8266WebServer server(80);

/**
 * Генерирует JSON-строку с тестовыми данными датчиков
 * В будущем будет заменена на реальные данные с физических датчиков
 * @return String JSON-строка с данными датчиков
 */
String getSensorDataJSON() {
  // Формируем JSON-объект с тестовыми значениями
  // temperature: температура в градусах Цельсия
  // humidity: влажность в процентах  
  // pressure: давление в мм ртутного столба
  String json = "{\"temperature\":22.5,\"humidity\":45,\"pressure\":755}";
  return json;
}

/**
 * Получает список MAC-адресов подключенных к точке доступа устройств
 * В текущей реализации возвращает заглушку (тестовые данные)
 * В будущем будет реализовано получение реальных MAC-адресов
 * @return String JSON-массив с MAC-адресами в формате ["AA:BB:CC:DD:EE:FF"]
 */
String getConnectedMACs() {
  String macs = "[";
  // Получаем количество подключенных станций к AP
  uint8_t count = WiFi.softAPgetStationNum();
  
  if (count > 0) {
    // В реальной реализации здесь будет код для получения 
    // реальных MAC-адресов подключенных устройств
    // Для тестирования возвращаем один заглушечный MAC-адрес
    macs += "\"1A:2B:3C:4D:5E:6F\"";
  }
  // Закрываем JSON-массив
  macs += "]";
  return macs;
}

/**
 * Обработчик главной страницы "/status"
 * Отправляет HTML-страницу с текущим статусом устройства
 * Использует send_P() для отправки данных из PROGMEM (экономия RAM)
 */
void handleStatus() {
  // Отправляем HTTP-ответ 200 OK с типом контента text/html
  // STATUS_PAGE - константа из web_pages.h, хранится во флеш-памяти
  server.send_P(200, "text/html", STATUS_PAGE);
}

/**
 * Обработчик страницы характеристик "/attributes"
 * Отправляет HTML-страницу со всеми статическими характеристиками
 */
void handleAttributes() {
  server.send_P(200, "text/html", ATTRIBUTES_PAGE);
}

/**
 * Обработчик страницы датчиков "/sensors"
 * Отправляет HTML-страницу для управления датчиками
 */
void handleSensors() {
  server.send_P(200, "text/html", SENSORS_PAGE);
}

/**
 * Обработчик страницы настроек "/settings"
 * Отправляет HTML-страницу для настройки системы
 */
void handleSettings() {
  server.send_P(200, "text/html", SETTINGS_PAGE);
}

/**
 * API-эндпоинт "/api/status" - получение текущего статуса устройства
 * Возвращает полную информацию о состоянии системы в формате JSON
 * Используется как веб-интерфейсом, так и мобильным приложением
 */
void handleApiStatus() {
  // Начинаем формирование JSON-объекта
  String json = "{";
  
  // === Системная информация ===
  json += "\"freeHeap\":" + String(ESP.getFreeHeap()) + ",";        // Свободная RAM в байтах
  json += "\"totalHeap\":" + String(80192) + ",";                  // Общая RAM (80KB = 80192 байт)
  json += "\"fsUsed\":125,";                                       // Использовано FS (заглушка)
  json += "\"fsTotal\":3072,";                                     // Общий размер FS (3MB = 3072 KB)
  json += "\"uptime\":" + String(millis() / 1000) + ",";           // Время работы в секундах
  json += "\"updateInterval\":5,";                                 // Интервал обновления (заглушка)
  
  // === Wi-Fi статус ===
  json += "\"wifiMode\":\"STA\",";                                 // Режим работы (STA = Station)
  // Проверяем статус подключения к Wi-Fi
  json += "\"wifiConnected\":" + String(WiFi.status() == WL_CONNECTED ? "true" : "false") + ",";
  json += "\"ssid\":\"" + String(WiFi.SSID()) + "\",";             // Имя подключенной сети
  json += "\"ipAddress\":\"" + WiFi.localIP().toString() + "\",";   // IP-адрес устройства
  
  // === Подключенные пользователи (к AP) ===
  json += "\"connectedClients\":" + String(WiFi.softAPgetStationNum()) + ","; // Текущее количество
  json += "\"maxClients\":1,";                                    // Максимальное количество (заглушка)
  json += "\"macAddresses\":" + getConnectedMACs() + ",";          // Список MAC-адресов
  
  // === Данные датчиков ===
  json += "\"sensors\":" + getSensorDataJSON();                    // Тестовые данные датчиков
  
  // Закрываем JSON-объект
  json += "}";
  
  // Отправляем JSON-ответ с правильным Content-Type
  server.send(200, "application/json", json);
}

/**
 * API-эндпоинт "/api/sensors/list" - получение списка всех датчиков
 * Возвращает конфигурацию всех датчиков в системе
 */
void handleApiSensorsList() {
  // Формируем JSON-массив с тремя тестовыми датчиками
  String json = "{\"sensors\":[";
  
  // Датчик 1: Температура
  json += "{\"id\":1,\"name\":\"Температура\",\"type\":\"DHT22\",\"unit\":\"°C\",";
  json += "\"minVal\":-10,\"maxVal\":50,\"pin\":2,\"enabled\":true},";
  
  // Датчик 2: Влажность  
  json += "{\"id\":2,\"name\":\"Влажность\",\"type\":\"DHT22\",\"unit\":\"%\",";
  json += "\"minVal\":0,\"maxVal\":100,\"pin\":2,\"enabled\":true},";
  
  // Датчик 3: Давление (отключен по умолчанию)
  json += "{\"id\":3,\"name\":\"Давление\",\"type\":\"BME280\",\"unit\":\"мм рт.ст.\",";
  json += "\"minVal\":700,\"maxVal\":800,\"pin\":4,\"enabled\":false}";
  
  json += "]}";
  
  server.send(200, "application/json", json);
}

/**
 * API-эндпоинт "/api/settings" - управление системными настройками
 * Поддерживает два метода:
 * - GET: получение текущих настроек
 * - POST: сохранение новых настроек
 */
void handleApiSettings() {
  if (server.method() == HTTP_GET) {
    // Возвращаем текущие настройки (заглушки для тестирования)
    String json = "{\"ssid\":\"Home_WiFi\",\"password\":\"******\",\"updateInterval\":5,\"maxClients\":1}";
    server.send(200, "application/json", json);
  } 
  else if (server.method() == HTTP_POST) {
    // В будущем здесь будет код для парсинга JSON и сохранения настроек в LittleFS
    // Сейчас просто возвращаем успех
    server.send(200, "application/json", "{\"status\":\"success\"}");
  }
}

/**
 * API-эндпоинт "/api/sensors/toggle/:id" - переключение состояния датчика
 * Метод POST, принимает ID датчика из URL и параметр enabled из тела запроса
 * Включает или выключает датчик без его удаления из системы
 */
void handleApiSensorsToggle() {
  // В будущем здесь будет логика переключения состояния датчика
  // Сейчас просто возвращаем успех
  server.send(200, "application/json", "{\"status\":\"success\"}");
}

/**
 * API-эндпоинт "/api/sensors/delete/:id" - удаление датчика
 * Метод DELETE, принимает ID датчика из URL
 * Полностью удаляет датчик из системы
 */
void handleApiSensorsDelete() {
  // В будущем здесь будет логика удаления датчика
  // Сейчас просто возвращаем успех  
  server.send(200, "application/json", "{\"status\":\"success\"}");
}

/**
 * Инициализация и запуск веб-сервера
 * Настраивает все маршруты (routes) и запускает сервер
 */
void initWebServer() {
  // === Настройка маршрутов для HTML-страниц ===
  server.on("/", handleStatus);                    // Главная страница
  server.on("/attributes", handleAttributes);      // Страница характеристик  
  server.on("/sensors", handleSensors);            // Страница датчиков
  server.on("/settings", handleSettings);          // Страница настроек
  
  // === Настройка API-эндпоинтов ===
  server.on("/api/status", handleApiStatus);                    // Текущий статус
  server.on("/api/sensors/list", handleApiSensorsList);         // Список датчиков
  server.on("/api/settings", handleApiSettings);                // Настройки системы
  server.on("/api/sensors/toggle/:id", HTTP_POST, handleApiSensorsToggle); // Переключение датчика
  server.on("/api/sensors/delete/:id", HTTP_DELETE, handleApiSensorsDelete); // Удаление датчика
  
  // Запускаем веб-сервер
  server.begin();
  Serial.println("🌐 Веб-сервер запущен");
}

/**
 * Обработка входящих веб-запросов
 * Эта функция должна вызываться регулярно в loop()
 * Проверяет наличие новых клиентских запросов и обрабатывает их
 */
void handleWebRequests() {
  // Обрабатываем клиентские запросы (если есть)
  server.handleClient();
}